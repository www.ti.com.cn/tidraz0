# EAGLE board TIDM-3PHMETER-ROGOWSKI (EAGLE 5.11), part 2 of 2
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via)
ACLK  (via drill 0.2)
  Top 0.254: MSP430F67791.9 122.88,81.5 v122.63,81.25
  Bottom 0.254: v122.63,81.25 122.63,86 124.13,87.5 134.63,87.5 137.63,90.5 137.66,90.5 142.61,95.95 153.14,95.95 SV2.3
ACT  (via drill 0.4)
  Top 0.254: MSP430F67791.29 127.63,91.5 129.13,93 129.13,99.75 127.38,101.5 123.13,101.5 121.63,103 121.63,124.75 111.13,135.25 111.13,146.75 102.88,155 78.55,155 LED_ACT.K | R72.1 123.38,161.75 122.63,162.5 | 122.63,162.5 v101.13,162.5 | 122.63,162.5 122.63,164.16 JP12.1
  Bottom 0.254: LED_ACT.K 76.48,152.85 87.63,164 99.63,164 v101.13,162.5
AGND  (via drill 0.36, 0.4, 0.41, 0.5, 0.6)
  Top 1.016: C9.2 52.23,46.4 R32.2 R15.2 | C11.2 67.03,46.3 R33.2 R17.2 | 82.78,30.59 82.7,30.51 L6.2 | C13.2 79.28,46.3 R34.2 R19.2
  other vias: 47.96,45.07 57.7,42.56 69.9,42.82 74.9,45.07 82.09,44.34 81.25,49.13 92.88,62 92.88,66.75 97.63,62 97.63,66.75 92.88,71.25 97.63,71.25 110.63,65.5 120.38,59.5 121.88,59.5 120.38,67 121.88,67 121.88,65.5 120.38,65.5 110.38,77.25 112.38,77.25 119.18,72.2 116.38,77.25 114.88,77.25 112.38,78.75 114.48,78.85 117.78,79.15 148.13,42.5 151.63,39.5 151.63,42.5 148.13,39.5 148.13,36.5 151.63,36.5 151.63,33.5 148.13,33.5 150.13,51.75 152.38,51.75 154.38,51.75 87.77,47.04 93.65,47.04 87.77,41.7 93.65,41.64 88.25,32.58 92.93,32.58 88.31,26.1 92.99,26.1 98.15,34.32 103.25,26.1 107.93,26.16 107.93,32.58 103.25,32.58 102.83,41.64 108.71,41.64 108.71,47.04 102.83,47.04 112.97,34.38 117.59,41.64 117.53,47.04 123.47,47.04 123.47,41.64 118.01,32.58 118.01,26.16 122.81,32.58 122.81,26.16 128.03,34.32 132.47,41.7 132.47,47.1 138.35,47.1 138.35,41.7 137.39,32.52 133.13,32.52 133.13,26.16 137.39,25.92
  pour Top: 111.88,79.5 119.63,79.5 119.63,76 123.63,71.5 123.63,54 155.63,54 155.63,18.75 82.52,18.75 82.63,41 46.63,41 46.63,49.5 82.63,49.5 82.63,57.5 88.13,57.5 88.13,75.99 108.37,75.99
  pour Bottom: 111.88,79.5 119.63,79.5 119.63,76 123.63,71.5 123.63,54 155.63,54 155.63,18.75 82.46,18.75 82.63,41 46.63,41 46.63,49.5 82.63,49.5 82.63,57.5 88.11,57.51 88.13,58.53 88.13,75.99 108.37,75.99
AUXVCC1  (via drill 0.2, 0.4)
  Top 0.254: MSP430F67791.124 120.13,74.4 v121.38,73.15 | v128.63,71.75 C26.1 | C27.1 130.78,69.35 v131.63,68.5
  Top 0.406: C26.1 128.63,69 128.98,69.35 C27.1
  Bottom 0.254: v128.63,71.75 122.78,71.75 v121.38,73.15
  Bottom 0.406: C63.1 131.6,65.54 | 153.63,67.9 SV1.3
  Bottom 0.61: C63.1 131.6,68.46 v131.63,68.5 | 131.6,65.54 134.13,63 151.13,63 153.63,65.5 153.63,67.9
AUXVCC2  (via drill 0.2)
  Top 0.254: MSP430F67791.123 119.63,74 v120.38,73.25 | C24.1 v125.63,70.75
  Top 0.406: C24.1 125.63,69.5 125.78,69.35 C25.1
  Bottom 0.254: v125.63,70.75 122.88,70.75 v120.38,73.25
  Bottom 0.61: v125.63,70.75 131.88,70.75 137.13,65.5 150.13,65.5 151.18,66.55 SV1.1
AUXVCC3  (via drill 0.3, 0.4)
  Top 0.254: C43.1 128.26,81.12 | MSP430F67791.3 124.88,78.5 127.53,81.15 C43.1 | C43.1 128.13,81 128.28,81.15 C44.1 130.28,81.15 v131.63,82.5 | v142.88,77.25 142.88,73.75 145.13,71.5 AUXVCC3.2
  Bottom 0.254: v131.63,82.5 138.93,82.5 142.83,78.6 142.83,77.3 v142.88,77.25
AVCC  (1 unrouted)
  Top 0.254: 118.13,71 118.08,70.95 C31.1 | MSP430F67791.121 118.63,74.33 118.13,73.83 118.13,70.95 C31.1 | C31.1 117.93,70.95 117.88,71 118.03,71.15
  Top 0.406: C29.1 118.13,69.75 118.03,69.85
  Top 0.61: 118.03,69.85 C31.1
BTN1  (via drill 0.2, 0.4)
  Top 0.254: v121.63,82.5 MSP430F67791.11 | R53.2 139.74,142.26 | R53.2 139.48,146.7 BTN4.2 | R53.2 139.48,139.15 v139.63,139
  Bottom 0.254: v121.63,82.5 121.63,86.5 123.63,88.5 134.13,88.5 136.63,91 136.63,116 138.13,117.5 138.13,137.5 v139.63,139
BTN2  (via drill 0.2, 0.36)
  Top 0.254: MSP430F67791.10 122.13,82 v121.63,81.5 | BTN2.2 139.48,126 R50.2 139.48,120.35 v137.13,118
  Bottom 0.254: v121.63,81.5 121.13,81.5 120.63,82 120.63,86.75 123.38,89.5 133.63,89.5 135.63,91.5 135.63,116.5 v137.13,118
BTN3  (via drill 0.2, 0.36)
  Top 0.254: MSP430F67791.4 123.13,79 v121.63,77.5 | BTN1.2 129.78,125.91 R49.2 129.78,120.35 v132.13,118
  Bottom 0.254: v121.63,77.5 120.88,77.5 119.63,78.75 119.63,80.5 118.63,81.5 118.63,87.25 122.88,91.5 132.63,91.5 133.63,92.5 133.63,116.5 v132.13,118
BTN4  (via drill 0.2, 0.4)
  Top 0.254: MSP430F67791.5 122.63,79.5 v121.63,78.5 | R52.2 130.13,142.35 | R52.2 129.78,146.61 BTN3.2 | R52.2 129.78,140.35 v131.13,139
  Bottom 0.254: v121.63,78.5 121.13,78.5 120.63,79 120.63,80.75 119.63,81.75 119.63,87 123.13,90.5 133.13,90.5 134.63,92 134.63,117 133.13,118.5 133.13,137 v131.13,139
CBOUT  (via drill 0.2)
  Top 0.254: MSP430F67791.91 109.13,83 v109.38,82.75
  Bottom 0.254: v109.38,82.75 116.72,82.75 119.13,80.34 119.13,78.5 122.08,75.55 129.26,75.55 129.58,75.55 131.13,74 146.38,74 153.13,80.75 153.27,80.75 JP13.1
COM0  (via drill 0.2)
  Top 0.254: MSP430F67791.22 121.13,88 v113.63,95.5 | LCD1.COM0 94.51,146.63 v109.38,131.75
  Bottom 0.254: v113.63,95.5 113.63,127.5 v109.38,131.75
COM1  (via drill 0.2)
  Top 0.254: MSP430F67791.23 121.63,88.5 v114.63,95.5 | v109.38,133.25 109.38,133.27 96.75,145.91 96.75,146.59 LCD1.COM1
  Bottom 0.254: v114.63,95.5 114.63,128 v109.38,133.25
COM2  (via drill 0.2)
  Top 0.254: MSP430F67791.24 122.13,89 v115.63,95.5 | LCD1.COM2 99.33,144.81 v109.38,134.75
  Bottom 0.254: v115.63,95.5 115.63,128.5 v109.38,134.75
COM3  (via drill 0.2)
  Top 0.254: MSP430F67791.25 122.63,89.5 v116.63,95.5 | v109.38,136.25 109.38,136.32 101.83,143.87 101.83,146.59 LCD1.COM3
  Bottom 0.254: v116.63,95.5 116.63,129 v109.38,136.25
CUR1+
  Top 0.61: I1+.TP 103.11,17.62 103.61,18.12 103.61,20.63 TVS2.C
  Top 0.813: R21.1 101.21,24.99 R22.2 101.21,21.24 101.79,20.66 TVS2.C
CUR1-
  Top 0.61: I1-.TP 108.19,17.68 107.69,18.18 TVS2.A
  Top 0.813: R23.1 109.99,25.11 R26.1 110.03,22.98 110.03,21.18 109.51,20.66 TVS2.A
CUR2+
  Top 0.61: I2+.TP 117.94,17.69 118.49,18.24 118.49,20.63 TVS3.C
  Top 0.813: R30.1 115.98,24.99 R29.2 115.97,21.18 116.49,20.66 TVS3.C
CUR2-
  Top 0.61: I2-.TP 123.02,17.73 122.57,18.18 TVS3.A
  Top 0.813: R31.1 124.87,25.11 R104.1 124.85,23.01 124.85,21.24 124.27,20.66 TVS3.A
CUR3+
  Top 0.61: R122.2 131,22.98 131,21.16 131.5,20.66 TVS4.C 133.19,18.3 132.76,17.87 I3+.TP
  Top 0.813: R123.1 131.05,25.21 R122.2
CUR3-
  Top 0.61: R125.1 139.5,22.98 139.5,21.16 139,20.66 TVS4.A 137.39,20.57 137.39,18.36 137.84,17.91 I3-.TP
  Top 0.813: R124.1 139.45,24.96 R125.1
CURN+
  Top 0.61: IN+.TP 88.16,17.79 88.55,18.18 88.55,20.63 TVS1.C
  Top 0.813: TVS1.C 86.79,20.66 86.21,21.24 R128.2 86.22,25.07 R129.1
CURN-
  Top 0.61: IN-.TP 93.24,17.57 92.75,18.06 92.75,20.59 TVS1.A
  Top 0.813: TVS1.A 94.39,20.66 95.03,21.3 95.03,23.01 R131.1 95.05,24.99 R130.1
DB9_+12V
  Top 0.406: D26.1 D25.1 28.19,158.53 30.74,158.53 C55.+ 30.81,153 | R63.2 31.02,150.41 | R63.2 30.81,153 | U1.8 41.22,150.41 34.84,150.41 34.56,150.12 30.83,150.12 R63.2 | Q1.E 30.71,150.2 R63.2 | 30.81,153 C54.2
DB9_-12V  (via drill 0.6)
  Top 0.406: v29.56,156 D24.2 28.01,153.05 C54.1 R67.1 | U1.5 34.96,154.16 34.56,153.75 33.41,153.75 R66.2 33.31,156 | 33.31,156 C56.- | v34.81,156 33.31,156
  Bottom 0.406: v29.56,156 v34.81,156
DB9_GND  (via drill 0.6)
  Top 0.406: 32.06,161.4 C55.- | 32.06,161.4 C56.+ 36.29,161.4 38.33,159.37 41.12,159.37 U2.3 | v20.31,163.5 D27.2 | v32.06,163.38 32.06,161.4
  Bottom 0.406: RS-232.G1 15.06,166.5 14.93,166.38
  Bottom 0.61: 10.81,159.5 10.91,159.61 RS-232.5 16.48,159.68 v20.31,163.5 20.31,166 21.31,167 29.93,167 32.06,164.88 v32.06,163.38
  Bottom 1.016: RS-232.G2 10.81,145.85 10.81,159.5 10.81,162.25 14.93,166.38 15.16,166.61 15.16,166.64
DGND  (via drill 0.3, 0.36, 0.4, 0.5, 0.6)
  Top 0.406: U2.5 46.96,158.09 46.96,158.1 v48.23,158.1
  Top 0.61: C42.2 84.51,77.77 U$1.VO-
  Top 0.813: R39.1 75.41,81.59 75.41,81.64 77.95,81.64 | 77.95,81.64 77.95,81.73 C101.- 77.93,81.67 77.95,81.64 | ZD3.A 78.52,84.5 78.46,84.44 78.46,82.15 77.95,81.64
  Bottom 0.406: v48.23,158.1 48.99,158.1
  other vias: 109.63,91.25 128.13,96.5 129.63,103.5 104.13,83.5 130.63,105.5 132.63,109 125.88,81.75 130.88,77.75 134.63,79.75 134.63,75.75 109.63,89.25 109.63,90.25 107.13,103 107.13,107 86.63,132.5 74.13,132.5 61.63,132.5 89.16,99.99 76.13,162.5 115.13,169.62 119.01,169.62 122.88,169.62 125.38,60.75 148.4,61.24 148.42,58.93 125.38,56.35 86.63,125.5 74.13,125.5 61.63,125.5 130.38,72.8 132.63,111.5 132.63,113.5 132.63,115.5 54.45,172.16 49.7,167.41 49.7,172.16 49.7,176.66 54.45,176.66 54.45,167.41 150.13,56.75 152.38,56.75 154.38,56.75
  pour Top (rank 2): 43.13,109.25 49.38,103.25 75.63,103.25 75.63,76.5 108.38,76.5 111.63,80 120.13,80 120.13,76.25 arc13 124.13,71.75 124.13,54.51 155.63,54.5 155.63,150.5 143.13,150.5 143.13,153.5 132.13,153.5 132.13,170 140.13,170 140.13,178.5 48.63,178.5 48.63,137 19.63,137 19.63,125 9.13,125 9.13,109 15.63,109
  pour Bottom (rank 2): 43.13,109.25 49.38,103.25 75.63,103.25 75.63,76.5 108.38,76.5 111.63,80 120.13,80 120.13,76.25 124.13,71.75 124.13,54.51 155.63,54.5 155.63,150.5 143.13,150.5 143.13,153.5 132.13,153.5 132.13,170 140.13,170 140.13,178.5 48.63,178.5 48.63,137 19.63,137 19.63,125 9.13,125 9.13,109 15.63,109.14
DRESET  (via drill 0.36)
  Top 0.254: v49.13,105 49.63,104.5 89.63,104.5 91.13,103 91.13,90.5 104.13,77.5 MSP430F67791.102
  Bottom 0.254: JP5.2 25.45,114.75 32.88,114.75 39.38,114.75 v49.13,105
DTCK  (via drill 0.36)
  Top 0.254: v50.13,105.5 50.63,105 89.88,105 91.63,103.25 91.63,90.75 104.38,78 MSP430F67791.101
  Bottom 0.254: JP6.2 25.45,117.29 32.34,117.29 33.13,116.5 34.13,115.5 40.13,115.5 v50.13,105.5
DTDI  (via drill 0.36)
  Top 0.254: v52.13,106.5 52.63,106 90.38,106 92.63,103.75 92.63,91.25 104.88,79 MSP430F67791.99
  Bottom 0.254: JP8.2 25.54,122.28 30.3,122.28 32.59,120 36.65,120 38.63,120 v52.13,106.5
DTDO  (via drill 0.36)
  Top 0.254: v53.13,107 53.63,106.5 90.63,106.5 93.13,104 93.13,91.5 105.13,79.5 MSP430F67791.98
  Bottom 0.254: JP9.2 25.45,124.91 29.2,124.91 33.1,121.01 37.13,121.01 | 37.13,121.01 37.16,121.01 | v53.13,107 39.13,121 37.15,121 37.13,121.01
DTMS  (via drill 0.36)
  Top 0.254: v51.13,106 51.63,105.5 90.13,105.5 92.13,103.5 92.13,91 104.63,78.5 MSP430F67791.100
  Bottom 0.254: JP7.2 25.45,119.83 30.8,119.83 31.3,119.83 34.63,116.5 40.63,116.5 v51.13,106
DVCC  (via drill 0.5, 0.6)
  Top 0.254: R41.2 132.48,88.85 | U2.8 46.63,161.99 49.5,161.99 | R65.1 53.13,151.5 54.13,152.5 54.13,161.5 53.65,161.99 53.06,161.99 | R53.1 R52.1 | R50.1 R49.1 | 134.69,83.5 134.56,83.38 IC1.8 134.51,83.37 133.22,83.37 132.82,83.78 R40.2 | 53.06,161.99 51.28,161.99 | 51.28,161.99 49.5,161.99 | R70.2 49.38,161.87 49.5,161.99 | 51.28,161 51.28,161.98 51.28,161.99 | C57.1 52.88,161.81 53.06,161.99 | 124.13,105.65 R47.1 124.16,107.62 IRDA.P$1 | MSP430F67791.126 121.13,74.9 122.03,74 C35.1
  Top 0.3: 124.13,105.65 C51.1 | 137.13,88.85 141.98,88.85 142.13,89 | 137.13,88.85 R41.2 | 137.13,88.85 137.13,83.5 | 137.13,83.5 137.13,81.9 C41.2 | 134.56,83.38 137.01,83.38 137.13,83.5
  Top 0.305: R51.1 31.13,125 23.55,132.53 JP10.2 | R65.1 51.73,148.6 v51.63,148.5
  Top 0.406: 51.28,161 R71.1 | 123.63,72.5 C33.1 124.13,72.4 | R53.1 137.78,150.65 140.13,153 | R50.1 137.78,129.65 142.63,134.5
  Top 0.508: 130.13,159 129.93,159.2 | RF1.9 70.1,168.03 70.48,167.65 R79.1 C58.+ 76.28,167.3 C59.2 76.28,171.03 78.36,173.1 EZ-RF.2 | IRDA.P$1 128.51,107.62 128.63,107.5 v128.63,105.5 | 137.13,110 v131.63,110
  Top 0.61: v102.44,148.41 R61.1 | v97.1,148.41 R60.1 | v92.02,148.41 R59.1 | v86.94,148.41 R58.1 | v74.24,148.41 R57.1 | v69.16,148.41 R56.1 | v64.08,148.41 R55.1 | R54.1 v58.62,148.41 58.53,148.5 v51.63,148.5 | 124.13,72.4 v124.13,63 R36.1 | C33.1 C35.1 | v70.38,162.25 70.48,162.35
  Top 0.679: 133.68,63.04 133.63,63
  Top 0.813: 129.93,159.2 OPTO1.1 | v99.13,80 88.63,90.5 81.21,90.5 | 81.21,90.5 80.21,89.5 JP3.2 | 133.68,63.04 137.13,66.5 137.13,73 142.13,78 142.13,89 142.13,93 137.13,98 137.13,110 137.13,115 142.63,120.5 142.63,134.5 142.63,150.5 140.13,153 132.63,153 130.13,155.5 130.13,159 130.13,167 | DVCC.4 DVCC.3 DVCC.2 DVCC.1 130.13,174.31 130.13,167 | OPTO2.1 129.95,166.82 130.13,167 | 70.48,162.35 R79.1 | R36.1 | 124.18,63.04 v124.13,63 133.63,63 | 81.21,90.5 v81.21,102.55 | v81.21,102.55
  Bottom 0.508: v128.63,105.5 128.63,108.5 130.13,110 v131.63,110
  Bottom 0.61: v102.44,148.41 v97.1,148.41 v92.02,148.41 v86.94,148.41 v74.24,148.41 v69.16,148.41 v64.08,148.41 v58.62,148.41
  Bottom 0.813: 47.13,131 47.13,117 56.63,107.5 77.81,107.5 81.21,104.1 v81.21,102.55 | 47.13,131 47.13,132 | 47.13,132 47.13,133 | 47.13,134 47.13,133 | 47.13,134 47.13,144 v51.63,148.5 61.13,158 66.13,158 v70.38,162.25 | v99.13,80 115.23,80 118.13,77.09 118.13,64 119.13,63 v124.13,63 | JP10.2 21.64,132.51 21.63,132.5 45.63,132.5 | 45.63,132.5 47.13,134 | 47.13,131 45.63,132.5 | 46.63,132.5 47.13,133 | 45.63,132.5 46.63,132.5 | 47.13,132 46.63,132.5
DVSYS_VDSYS  (via drill 0.2, 0.4)
  Top 0.254: 129.38,74.02 C34.1 128.36,73 v126.88,73 | v106.38,96.75 C36.1 106.41,97.88 106.93,97.88 108.18,96.63 108.53,96.63 109.4,95.77 109.4,94.75 110.13,94.01 110.13,94 120.63,83.57 MSP430F67791.125 120.63,74.65 122.48,73 v122.63,73 | MSP430F67791.69 106.63,94 v106.38,93.75
  Top 0.406: 129.38,74.02 130.61,74.02 v131.88,72.75
  Bottom 0.254: v106.38,96.75 v106.38,93.75 | v122.63,73 v126.88,73
  Bottom 0.406: v131.88,72.75 146.41,72.75 147.67,71.48 AUXVCC3.3
EXT
  Top 0.813: JP10.3
  Top 1.016: JTAG.4 16.85,128.72 18.13,130 JP10.3
EZ-RF_RXD  (via drill 0.36)
  Top 0.254: MSP430F67791.36 125.38,95 126.63,96.25 v126.63,96.5
  Bottom 0.254: EZ-RF.6 108.13,174 111.13,171 111.13,165 123.63,152.5 123.63,143 132.38,134.25 132.38,120.75 127.63,116 127.63,99 126.63,98 v126.63,96.5
EZ-RF_TXD  (via drill 0.36)
  Top 0.254: MSP430F67791.37 125.13,95.5 125.63,96 v125.63,97.5
  Bottom 0.254: v125.63,97.5 125.63,98.25 126.63,99.25 126.63,116.5 131.63,121.5 131.63,133.5 122.63,142.5 122.63,152 110.13,164.5 110.13,170.5 107.63,173 77.51,173 77.01,173.5 77.01,173.91 EZ-RF.1
I1+
  Top 0.254: MSP430F67791.114 115.13,73.5 114.63,73 114.63,67.5 113.63,66.5
  Top 0.406: 113.63,66.5 110.63,63.5 110.63,54.96 104.45,48.78 102.17,48.78 101.21,47.82 101.21,36.66 C20.1
  Top 0.61: 101.34,36.53 101.21,36.66
  Top 0.813: R28.2 101.34,36.53
I1-
  Top 0.254: MSP430F67791.115 115.63,73.25 115.13,72.75 115.13,67 114.13,66
  Top 0.406: 114.13,66 111.63,63.5 111.63,54.5 109.99,52.86 C7.2
  Top 0.813: R27.2 109.91,35.97 C7.2
I2+
  Top 0.254: MSP430F67791.116 116.13,73 115.63,72.5 115.63,66.5 114.63,65.5
  Top 0.4: 114.48,55.16 112.63,57
  Top 0.406: 114.63,65.5 112.63,63.5 112.63,57 | C64.1 116,53.63 114.48,55.16
  Top 0.813: C64.1 116,33.65 R106.2
I2-
  Top 0.254: MSP430F67791.117 116.63,72.75 116.13,72.25 116.13,66 115.13,65
  Top 0.406: 115.13,65 113.63,63.5 113.63,57.5 121.15,49.98 123.59,49.98 124.87,48.7 C5.2
  Top 0.813: R105.2 124.76,35.94 C5.2
I3+
  Top 0.254: MSP430F67791.118 117.13,72.5 116.63,72 116.63,65.5 115.63,64.5
  Top 0.406: 115.63,64.5 114.63,63.5 114.63,58 121.63,51 129.83,51 131.03,49.8 131.03,36.05 C80.1
  Top 0.813: C80.1 131.13,36.03 R127.2
I3-
  Top 0.254: MSP430F67791.119 117.63,72.25 117.13,71.75 117.13,65 116.13,64
  Top 0.406: 116.13,64 115.63,63.5 115.63,58.5 122.13,52 137.17,52 139.37,49.8 139.37,36.11 C77.2
  Top 0.813: R126.2 139.45,33.48 C77.2
IN+
  Top 0.254: MSP430F67791.109 112.63,73.5 108.63,69.5 108.63,68
  Top 0.406: 108.63,68 108.63,56 103.63,51 88.01,51 86.15,49.14 C85.1
  Top 0.813: R133.2 86.17,36.03 C85.1
IN-
  Top 0.254: MSP430F67791.110 113.13,73.25 109.63,69.75 109.63,68
  Top 0.406: 109.63,68 109.63,55.5 104.13,50 96.85,50 95.03,48.18 95.03,36.07 C82.2
  Top 0.813: R132.2 94.92,35.91 C82.2
INT
  Top 1.016: JTAG.2 15.89,131.26 19.7,135.07 JP10.1
IR_RXD
  Top 0.254: MSP430F67791.20 126.88,87 130.38,90.5 132.38,90.5 135.63,93.75 135.63,103.5 129.61,109.53 IRDA.P$3 128.47,109.5
IR_SD
  Top 0.254: MSP430F67791.19 127.13,86.5 130.63,90 132.63,90 136.13,93.5 136.13,104 129.63,110.5 128.52,110.5 IRDA.P$4
IR_TXD
  Top 0.254: MSP430F67791.21 126.63,87.5 130.13,91 132.14,91 135.15,94.01 135.15,102.98 129.56,108.58 IRDA.P$2 128.42,108.5
LED1
  Top 0.254: MSP430F67791.28 127.88,91 129.63,92.75 129.63,100 127.63,102 123.38,102 122.13,103.25 122.13,125 111.63,135.5 111.63,147 103.13,155.5 73.97,155.5 LED3.K
LED2
  Top 0.254: MSP430F67791.27 128.13,90.5 130.13,92.5 130.13,100.25 127.88,102.5 123.63,102.5 122.63,103.5 122.63,125.25 112.13,135.75 112.13,147.25 103.38,156 69.39,156 LED2.K
LED3
  Top 0.254: MSP430F67791.26 128.38,90 130.63,92.25 130.63,100.5 128.13,103 123.88,103 123.13,103.75 123.13,125.5 112.63,136 112.63,147.5 103.63,156.5 64.81,156.5 LED1.K
LED4
  Top 0.254: MSP430F67791.45 119.13,121 110.13,130 110.13,146.25 102.38,154 90.13,154 89.1,152.97 LED4.K
LED5  (via drill 0.2)
  Top 0.254: MSP430F67791.15 121.63,84.5 v112.63,93.5
  Bottom 0.254: v112.63,93.5 112.63,127 108.63,131 108.63,144.5 109.63,145.5 109.63,147.75 103.38,154 95.38,154 94.23,152.85 LED5.K
LED6  (via drill 0.2)
  Top 0.254: MSP430F67791.12 122.13,83 v111.63,93.5
  Bottom 0.254: v111.63,93.5 111.63,126.5 107.63,130.5 107.63,145 108.63,146 108.63,147.25 103.03,152.85 LED6.K
LINE1
  Top 1.016: 16.48,23.65 L1.1 16.4,23.65 | 16.4,23.65 16.48,23.73 | 16.4,23.65 16.33,23.58 16.33,20.83 16.48,20.68 16.4,20.6 R1.2 | R1.2 16.4,20.52 16.48,20.43 16.33,20.28 | LINE1.TP 16.33,20.47 R1.2
LINE2
  Top 1.016: L3.1 41.69,24.18 41.88,23.99 41.8,23.9 R2.2 42.08,20.5 LINE2.TP
LINE3
  Top 1.016: R3.2 68.21,20.77 68.3,20.68 67.84,20.22 | L5.1 68.23,23.8 68.3,23.73 68.21,23.65 R3.2 | LINE3.TP 67.84,20.41 R3.2
MCLK  (via drill 0.2)
  Top 0.254: v121.63,80.5 MSP430F67791.7
  Bottom 0.254: v121.63,80.5 123.13,80.5 123.63,81 123.63,85.5 124.63,86.5 135.13,86.5 141.93,93.3 153.02,93.3 SV2.4
N$1
  Top 1.016: C100.- 55.45,79.19 U$1.26
N$2
  Top 1.016: C100.+ 60.53,79.19 U$1.22
N$3
  Bottom 0.254: OPTO2.4 ACT.2
N$4
  Top 0.254: R56.2 72.17,149.46 LED3.A
N$5
  Top 0.406: D44.C 142.93,68.16 AUXVCC3.1
N$7
  Top 0.254: R55.2 67.09,149.46 LED2.A
N$8
  Top 0.61: R6.2 12.99,29.66 13,29.68 13.05,29.63 R5.1
N$9
  Top 0.254: U1.2 49.92,151.62 R65.2
N$10
  Top 0.254: JP4.1 25.45,114.75 19.6,114.75 19.08,115.28 R48.2
N$11
  Bottom 0.254: OPTO2.3 ACT.1
N$12
  Top 0.254: OPTO2.2 127.2,162.57 126.38,161.75 R72.2
N$13
  Top 1.016: 11.17,33.11 11.15,33.13 | 11.17,33.11 R7.2 | R6.1 11.27,33 11.17,33.11
N$14
  Top 0.679: R14.2 R15.1
  Top 1.016: R14.2 52.13,40.33 51.28,39.48 13.69,39.48 11.15,36.94 11.15,35.16 11.17,35.14 R7.1
N$15
  Top 1.016: 37.87,30.54 37.82,30.59 | R9.2 37.87,30.54 | R8.1 37.94,30.46 37.87,30.54
N$16
  Top 1.016: R10.2 36.14,33.74 36.04,33.64 36.17,33.51 R9.1
N$17
  Top 0.254: U3.5 54.95,92.17 R38.2
N$18
  Top 1.016: R92.2 7.37,88.22 7.34,88.25 7.37,88.28 D18.A 3.23,88.46 3.02,88.25 2.87,88.39 D17.C
N$19
  Top 0.679: R16.2 R17.1
  Top 1.016: R16.2 64.13,39.38 62.2,37.45 36.8,37.45 36.29,36.94 36.29,36.18 36.04,35.92 36.14,35.82 R10.1
N$20
  Top 0.813: R106.1 115.97,31.45 C17.1 116.17,28.86 R30.2
N$21
  Top 0.254: R59.2 88.25,149.46 LED4.A
N$22
  Top 0.254: Q2.B R69.2
N$23
  Top 0.813: R31.2 124.74,28.92 C16.2 124.87,31.5 R105.1
N$24
  Top 0.406: RS-232.2 17.86,152.75 18.11,153 R67.2 24.06,153.35 R64.1
N$25
  Top 0.61: 120.45,37.89 C65.2 120.53,37.94 120.53,36.9 | C64.2 117.95,36.06 119.69,36.06 | 119.69,36.06 120.53,36.9 | C5.1 121.39,36.05 120.53,36.9 | 119.69,36.06 119.87,36.06 120.53,35.4 | 120.53,35.4 121.13,36 | 119.59,29.05 C17.2 | 119.59,29.05 120.53,30.06 | 120.53,30.06 120.53,35.4 | C16.1 121.6,29.05 120.53,30.06 | R29.1 119.68,23.02 120.53,23.88 | 119.59,29.05 119.74,28.93 120.53,28.14 | 120.53,28.14 121.37,28.98 | 120.53,23.88 120.53,28.14 | R104.2 121.39,23.02 120.53,23.88
  pour Top: 120.89,36.18 120.53,36.54 120.17,36.18 120.17,36.12 120.53,35.76 120.89,36.12
  pour Top: 119.87,29.1 120.53,28.44 121.13,29.1 121.19,29.16 120.53,29.76
N$26  (via drill 0.3)
  Top 0.406: U1.6 37.69,152.88 v37.56,152.76 | R62.1 37.51,148.5 v37.56,148.45
  Bottom 0.406: v37.56,148.45 v37.56,152.76
N$27
  Top 0.254: R60.2 93.33,149.46 LED5.A
N$28
  Top 0.406: R62.2 30.91,148.5 R63.1 28.76,148.4 Q1.B
N$29
  Top 1.016: R12.2 64.45,29.79 64.49,29.83 64.52,29.79 R11.1
N$30
  Top 0.254: R54.2 62.01,149.46 LED1.A
N$31
  Top 0.813: R127.1 131.05,31.59 C79.1 131.13,29.04 R123.2
N$32
  Top 0.61: 101.19,31.48 R28.1
  Top 0.813: 101.19,31.48 C19.1 101.34,28.91 R21.2
N$33
  Top 1.016: R12.1 62.62,29.99 62.71,30.08 62.62,30.17 R13.2
N$34
  Top 0.679: R18.2 R19.1
  Top 1.016: R13.1 72.38,34.67 76.43,38.72 76.43,41.51 76.38,41.56 R18.2
N$35
  Top 0.254: RF2.3 99.81,164.22 R74.2
N$36
  Top 0.254: R61.2 98.41,149.46 LED6.A
N$37
  Top 0.254: U3.4 53.62,94.49 53.13,94 C45.1
N$38
  Top 0.254: U3.3 53.38,95 52.38,94 51.48,94 R35.1 R37.2
N$39
  Top 0.813: 139.38,29.04 R124.2 | C78.2 139.38,29.04 | 139.38,29.04 R126.1
N$40
  Top 0.61: 134.38,29.04 135.25,29.91 | C78.1 136.13,29.04 135.25,29.91 | C80.2 134.5,36.03 135.25,36.78 | 136,36.03 135.25,36.78 | 136,36.03 C77.1 | 134.38,29.04 C79.2 | 135.25,28.16 134.38,29.04 | 135.25,28.16 136,28.91 | 136,36.03 136,35.91 135.25,35.16 | 135.25,35.16 134.5,35.91 | 135.25,36.78 C81.2 | 135.25,29.91 135.25,35.16 | R122.1 134.38,23.04 135.25,23.91 | 135.25,23.91 135.25,28.16 | R125.2 136.13,23.04 135.25,23.91
  pour Top: 135.25,29.41 134.88,29.04 135.25,28.66 135.63,29.04
  pour Top: 134.88,35.91 135.25,36.28 135.63,35.91 135.25,35.53
N$41
  Top 0.406: Q1.C 24.21,149.25 R64.2
N$42
  Top 0.813: R129.2 86.17,29.02 C84.1 86.21,31.59 R133.1
N$43
  Top 0.406: U1.7 34.94,151.62 34.56,152 33.46,152 R66.1
N$44
  Top 0.254: R58.2 83.17,149.46 LED_REACT.A
N$45
  Top 0.254: RF2.5 99.91,165.5 R76.2
N$46
  Top 0.254: R57.2 77.25,149.46 LED_ACT.A
N$47
  Top 1.016: 23.2,87.85 D20.A 23.06,87.91 22.96,87.82 22.68,87.56 20.92,85.8 | D19.C 19.02,87.99 20.92,86.1 20.92,85.8 | R93.2 20.92,85.57 20.92,85.8
N$48
  Top 0.254: IRDA.P$5 124.36,111.42 C52.1
  Top 0.3: R47.2 C52.1
N$49
  Top 0.406: D44.A 146.33,61.66 HD1.2
N$50
  Top 0.254: R79.2 RF1.7
N$51
  Top 0.254: R73.1 63.12,164.25 RF1.4
N$52
  Top 0.254: RF1.15 68.75,171.84 R87.2
N$53
  Top 0.254: RF1.6 60.61,165.5 R77.1
N$54
  Top 0.813: R130.2 94.92,28.93 C83.2 95.05,31.5 R132.1
N$55
  Top 0.254: RF2.10 90.14,168.03 R83.1
N$56
  Top 0.254: R84.1 93.58,169.25 RF2.12
N$57
  Top 0.254: R85.1 93.58,170.62 RF2.14
N$58
  Top 0.406: 28.48,164.16 D27.1 28.41,163.9 R78.1 33.75,165.75 33.75,165.72 38.84,160.63 U2.2
N$59
  Top 0.254: RF2.16 90.14,171.84 R86.1
N$60
  Top 0.254: RF2.18 90.24,173.12 R88.1
N$61
  Top 0.254: R91.1 91.52,174.75 91.92,174.35 93.6,174.35 RF2.20
N$62
  Top 0.61: C85.2 89.98,36.05 90.65,36.72 | 90.65,36.72 90.65,37.94 C86.2 | 90.65,36.72 91.32,36.05 C82.1 91.66,36.05 90.65,35.04 | 90.65,35.04 89.69,36 | R131.2 91.27,23.02 90.59,23.7 | 90.59,23.7 90.59,28.2 90.65,28.26 | 90.65,28.26 91.43,29.04 93.13,29.04 C83.1 | R128.1 89.92,23.02 90.59,23.7 | 89.85,29.06 C84.2 | 90.65,28.26 89.85,29.06 | 89.85,29.06 89.89,29.06 90.65,29.82 | 90.65,29.82 91.37,29.1 | 90.65,29.82 90.65,35.04
  pour Top: 90.65,36.42 90.11,35.88 90.65,35.34 91.19,35.88
  pour Top: 90.65,29.52 90.17,29.04 90.65,28.56 90.71,28.56 91.13,28.98 91.13,29.04
N$65
  Bottom 0.254: OPTO1.4 REACT.2
N$67  (via drill 0.6)
  Top 0.406: v24.31,165.75 R78.2 | D24.1 18.36,156 RS-232.3
  Bottom 0.406: RS-232.3 16.48,154.18 18.31,156 22.31,156 24.31,158 v24.31,165.75
N$68
  Bottom 0.254: OPTO1.3 REACT.1
N$69
  Top 0.406: D26.2 12.31,161 10.81,159.5 10.81,154.25 12.31,152.75 RS-232.7
N$71
  Top 0.406: D25.2 18.12,158.5 RS-232.4
N$72
  Top 0.254: OPTO1.2 127.2,155.07 126.38,154.25 R68.2
N$78
  Top 0.254: U3.1 54.39,95.99 54.13,96.25 C47.1
N$79
  Top 0.254: 49.64,152.94 Q2.E 48.43,153.3 48.02,152.88 U1.3
N$80  (via drill 0.5)
  other vias: 63.13,100 63.13,99 63.13,98
  pour Top (no thermals): 53.63,99.5 53.63,102 63.63,102 63.63,97.5 60.63,97.5 60.63,96 58.63,96 58.63,101 54.63,101 54.63,99.5
  pour Bottom (no thermals): 57.63,100 57.63,97.5 63.63,97.5 63.63,100.5 57.63,100.5
N$81
  Top 0.254: RF1.19 R90.2
N$82
  Top 0.406: C60.1 64.38,96.6 R95.1
N$83
  Top 0.254: R89.1 63.14,173.12 RF1.18
N$84
  Top 1.016: C39.2 7.4,69.37 R92.1
N$85
  Top 0.254: RF2.7 100.02,166.76 R80.2
N$86
  Top 0.254: RF2.9 99.94,168.03 R82.2
N$87
  Top 0.254: R81.1 91.94,166.5 92.17,166.73 93.6,166.73 RF2.8
N$88
  Top 0.254: R75.1 91.33,165.12 91.67,165.46 93.6,165.46 RF2.6
N$89
  Top 1.016: C46.2 20.69,68.62 R93.1
N$90
  Top 1.016: C50.2 34.87,68.81 R94.1
N$91
  Top 0.813: R23.2 109.92,27.18 110.03,27.3 110.03,29.02 C18.2 110.05,29.05 110.09,29.1 110.09,31.45 R27.1
N$92
  Top 0.254: U3.8 62.28,95 C61.1
  Top 0.406: C61.1 62.38,96.6 R95.2
N$93
  Top 0.254: R96.1 R97.2
N$94
  Top 1.016: D21.C 35.04,87.5 35.02,87.49 35.07,87.44 | R94.2 35.07,87.44 | D22.A 39.11,87.46 39.09,87.49 39.04,87.44 35.07,87.44
N$95
  Top 0.254: U3.7 60.39,94.49 60.88,94 60.88,92.4 R98.2 R97.1
N$97
  Top 0.61: C19.2 104.71,29.06 104.75,29.1 | 104.75,29.1 105.59,29.94 | 104.92,36.05 C20.2 | 104.92,36.05 105.65,36.78 | 105.65,36.78 105.65,37.91 C76.2 | C7.1 106.39,36.05 105.65,36.78 | 104.92,36.05 104.92,36.02 105.59,35.34 | 105.59,35.34 105.71,35.34 106.31,35.94 | 105.59,35.34 105.65,35.28 105.65,29.97 106.57,29.05 C18.1 106.51,29.05 105.71,28.26 | 105.71,28.26 105.59,28.26 104.75,29.1 | 105.71,28.26 105.71,23.88 105.77,23.82 | 105.77,23.82 106.55,23.04 R26.2 | R22.1 104.98,23.02 105.77,23.82
  pour Top: 105.65,29.64 105.05,29.04 105.65,28.44 106.25,29.04
  pour Top: 105.53,36.42 105.17,36.06 105.65,35.58 106.13,36.06 106.07,36.06 105.71,36.42
NEUTRAL  (via drill 0.5)
  Top 0.254: 49.76,1.63 49.76,2.14 49.76,2.4 50.26,2.9 50.26,3.16 50.26,3.92 | 51.65,6.11 51.65,5.58 51.79,5.44 51.28,4.94 | U3.9 58.14,95.51 58.13,95.5
  Top 1.016: 26.64,17.14 R1.1 | R3.1 78.37,28.79 L6.1
  Top 1.422: 26.64,17.14 26.64,6.46 31.21,1.63 47.72,1.63 | 47.72,1.63 49.76,1.63 73.12,1.63 77.19,5.7 77.19,7.78 NEUTRAL.TP 78.37,9.18 R3.1 | 47.72,1.63 47.72,2.14 51.65,6.11 51.96,6.63 R2.1 | 52.04,6.21 56.87,2.14 49.76,2.14 47.98,2.14 | 50.26,3.92 54.07,3.92 | 48.99,3.16 50.26,3.16 54.84,3.16 | 51.28,4.94 52.8,4.94
  Bottom 1.016: R3.1 78.13,17.73 78.13,29.5 68.63,39 46.13,39 44.63,40.5 44.63,49 46.33,50.2 53.83,50.2 57.99,55.35 U$1.N 57.99,63.15 53.63,67.5 46.13,67.5 44.56,69.08 C102.- 41.64,91.24 39.38,93.5 36.38,93.5 | D17.A 2.87,97.76 7.13,93.5 17.38,93.5 | 19.13,93.5 17.38,93.5 | 20.38,93.5 19.13,93.5 | 33.63,93.5 20.38,93.5 | 35.13,93.5 33.63,93.5 | 36.38,93.5 35.13,93.5 | D19.A 18.92,93.71 19.13,93.5 | D19.A 18.92,95.04 17.38,93.5 | D19.A 18.92,94.96 20.38,93.5 | D21.A 35.04,94.9 33.63,93.5 | D21.A 35.04,94.85 36.38,93.5 | D21.A 35.04,93.6 35.13,93.5
  other vias: 56.63,96 57.63,96 56.63,95 56.63,94 57.63,95 57.63,94 64.38,92 62.38,92 63.38,92 71.88,81 71.88,82 70.88,82 70.88,81 73.63,87 73.63,86 72.63,87 47.63,91 48.63,91 49.63,91 62.38,85.25 64.38,85.25 63.38,85.25
  pour Top (no thermals): 43.88,92.5 46.13,92.5 47.13,93.5 50.13,93.5 50.13,91 56.13,91 56.13,96.5 55.13,97.5 55.13,100.5 58.13,100.5 58.13,93 59.38,93 59.38,91.5 58.13,91.5 58.13,88 58.63,87.5 74.13,87.5 74.13,80.5 66.13,80.5 62.13,84.5 49.13,84.5 43.13,90.5 43.13,91.75
  pour Bottom (no thermals): 43.88,92.5 46.13,92.5 47.13,93.5 52.63,93.5 55.63,96.5 58.13,96.5 58.13,95.5 65.13,95.5 65.13,91.5 57.63,91.5 57.63,87.5 74.13,87.5 74.13,80.5 66.13,80.5 62.13,84.5 49.13,84.5 43.13,90.5 43.13,91.75
  pour Top (no thermals): 61.63,95.5 61.63,91.5 65.13,91.5 65.13,95.5
P1+1
  Top 0.61: R5.2 16.44,27.84 16.48,27.8 16.48,25.51
  Top 1.016: 16.48,25.51 16.48,25.35 L1.2 16.37,25.4 16.48,25.51 | C39.1 3.3,49.41 2.26,48.37 2.26,28.05 4.8,25.51 16.48,25.51
P2+1  (via drill 1.1)
  Top 1.016: R8.2 41.37,28.56 41.69,28.24 41.69,25.76 | 41.69,25.76 L3.2 | v34.77,25.76 41.69,25.76
  Bottom 1.016: C46.1 20.69,35.02 29.18,25.76 v34.77,25.76
P3+1  (via drill 1.1)
  Top 1.016: R11.2 68.26,27.84 68.3,27.8 68.23,27.73 L5.2 62.03,25.68 v61.95,25.76
  Bottom 1.016: U$1.L 39.68,58.87 35.02,54.21 35.02,49.39 34.77,49.13 34.87,49.03 C50.1 34.87,38.76 47.63,26 61.71,26 v61.95,25.76
R13  (via drill 0.2, 0.5)
  Top 0.254: MSP430F67791.32 125.38,93 126.88,94.5 126.88,94.51 127.38,95 v128.13,95 | R46.2 v132.38,100.5 R43.1
  Bottom 0.254: v132.38,100.5 132.38,98.48 129,95.11 128.24,95.11 v128.13,95
R23  (via drill 0.2, 0.5)
  Top 0.254: MSP430F67791.31 125.63,92.5 126.63,93.5 v128.13,93.5 | R43.2 v132.38,96.5 R42.1
  Bottom 0.254: v132.38,96.5 132.38,96.45 129.51,93.58 128.21,93.58 v128.13,93.5
R33  (via drill 0.2, 0.5)
  Top 0.254: MSP430F67791.30 126.63,92 v127.13,92.5 | v132.38,92.5 R42.2 133.28,93.65 134.01,94.38 C49.1
  Bottom 0.254: v127.13,92.5 v132.38,92.5
REACT  (via drill 0.4)
  Top 0.254: MSP430F67791.41 121.13,124.5 110.63,135 110.63,146.5 102.63,154.5 85.67,154.5 LED_REACT.K | v100.13,161.5 116.13,161.5 120.97,156.66 | 120.97,156.66 123.38,154.25 R68.1 | 120.97,156.66 JP11.1
  Bottom 0.254: LED_REACT.K 84.02,158.89 88.13,163 98.63,163 v100.13,161.5
RESET  (via drill 0.2)
  Top 0.254: C53.2 31.12,119.75 | RESET.1 35.6,118 34.37,119.24 31.25,119.24 C53.2 | C53.2 29.78,119.35 29.13,118.7 29.13,118
  Top 0.305: C53.2 R51.2 | v29.13,113 29.13,118
  Bottom 0.254: v29.13,113 28.13,112 23.63,112 22.88,112.75 22.88,115 21.86,116.02 JP5.3 20.36,116.02 16.64,119.74 | JTAG.11 12.12,118.58 13.28,119.74 16.64,119.74 | 16.64,119.74 16.64,119.75
RF_CCA  (via drill 0.2, 0.36)
  Top 0.254: MSP430F67791.90 110.13,83.5 v111.63,85 | v115.63,151.5 106.63,160.5 99.66,160.5 98.78,159.62 88.87,159.62 83.79,164.7 83.79,167.5 84.3,168 88.15,168 R83.2
  Bottom 0.254: v115.63,151.5 115.63,139 122.63,132 122.63,123 119.63,120 119.63,94.5 111.63,86.5 v111.63,85
RF_CLK  (via drill 0.36)
  Top 0.254: MSP430F67791.44 119.63,121.25 117.63,123.25 v117.63,124 | R86.2 88.13,171.84 85.73,171.84 82.13,168.25 82.13,164 88.13,158 100.13,158 v100.63,158.5
  Bottom 0.254: v117.63,124 117.63,129.5 110.63,136.5 110.63,148.5 v100.63,158.5
RF_CS  (via drill 0.2, 0.36)
  Top 0.254: MSP430F67791.94 110.13,81.5 v113.63,85 | R85.2 85.26,170.62 82.63,168 82.63,164.25 88.38,158.5 88.44,158.56 99.11,158.56 100.05,159.5 104.63,159.5 v117.63,146.5
  Bottom 0.254: v117.63,146.5 117.63,140 126.63,131 126.63,124 121.63,119 121.63,94 113.63,86 v113.63,85
RF_FIFO  (via drill 0.36)
  Top 0.254: MSP430F67791.40 121.63,99.5 v122.63,100.5 | v104.88,166.75 R80.1 | v84.63,165.12 R75.2
  Bottom 0.254: v122.63,100.5 122.63,118.5 127.13,123 127.13,132 118.63,140.5 118.63,150 106.13,162.5 106.13,165.5 v104.88,166.75 93.38,166.75 92.13,165.12 v84.63,165.12
RF_FIFOP  (via drill 0.36)
  Top 0.254: MSP430F67791.39 122.13,98.5 v122.63,99 | v106.13,168 101.86,168 R82.1 | v84.63,166.5 R81.2
  Bottom 0.254: v122.63,99 123.63,100 123.63,118 127.63,122 127.63,133 119.63,141 119.63,150.5 107.13,163 107.13,167 v106.13,168 92.63,168 91.38,166.5 v84.63,166.5
RF_GPIO1  (via drill 0.2, 0.36)
  Top 0.254: MSP430F67791.96 111.13,80.5 v115.63,85 | R90.1 70.61,174.5 v71.63,174.5
  Bottom 0.254: v115.63,85 115.63,85.5 123.63,93.5 123.63,97.5 125.63,99.5 125.63,117 128.63,120 128.63,135 121.63,142 121.63,151.5 109.13,164 109.13,170 107.13,172 74.13,172 v71.63,174.5
RF_GPIO2  (via drill 0.2, 0.36)
  Top 0.254: MSP430F67791.95 110.63,81 v114.63,85 | 58.63,172.97 R89.2 58.66,173 v57.13,173
  Bottom 0.254: v114.63,85 114.63,85.75 122.63,93.75 122.63,97.75 124.63,99.75 124.63,117.5 128.13,121 128.13,134 120.63,141.5 120.63,151 108.13,163.5 108.13,169.5 106.63,171 74.13,171 72.13,173 v57.13,173
RF_RESETCC  (via drill 0.2, 0.36, 0.4)
  Top 0.254: MSP430F67791.89 109.63,84 v110.63,85 | 104.37,165.5 106.13,165.5 107.13,166.5 v107.13,169 | 70.63,171.72 R87.1 70.61,172 v71.63,172 | v105.13,164.5 105.13,164.73 104.37,165.5 | 104.37,165.5 101.86,165.5 R76.1
  Bottom 0.254: v110.63,85 110.63,86.75 118.63,94.75 118.63,120.5 121.63,123.5 121.63,131.5 114.63,138.5 114.63,152.5 105.13,162 v105.13,164.5 | v107.13,169 106.13,170 73.63,170 v71.63,172
RF_SFD  (via drill 0.2, 0.36)
  Top 0.254: 84.21,168.83 83.13,167.75 83.13,164.5 88.63,159 98.87,159 99.9,160.03 105.6,160.03 v116.63,149 | MSP430F67791.93 109.63,82 v112.63,85 | 84.21,168.83 | 84.21,168.83 84.61,169.22 88.26,169.22 R84.2
  Bottom 0.254: v112.63,85 112.63,86.25 120.63,94.25 120.63,119.5 123.63,122.5 123.63,132.5 116.63,139.5 v116.63,149
RF_SIMO  (via drill 0.36)
  Top 0.254: MSP430F67791.43 120.13,121.5 118.63,123 v118.63,124 | R88.2 88.02,173.12 86.25,173.12 81.63,168.5 81.63,163.75 87.88,157.5 102.63,157.5 v102.88,157.75
  Bottom 0.254: v118.63,124 118.63,130 111.63,137 111.63,149 v102.88,157.75
RF_SOMI  (via drill 0.36)
  Top 0.254: MSP430F67791.42 120.63,121.75 119.63,122.75 v119.63,124 | v104.88,157 87.63,157 81.13,163.5 81.13,168.75 86.77,174.38 87.17,174.79 88.25,174.79 R91.2
  Bottom 0.254: v119.63,124 119.63,130.5 112.63,137.5 112.63,149.5 v104.88,157
RF_VREG_EN  (via drill 0.2, 0.4)
  Top 0.254: MSP430F67791.88 109.13,84.5 v109.63,85 | v104.13,163.25 104.13,163.92 103.86,164.19 101.93,164.19 R74.1
  Bottom 0.254: v109.63,85 109.63,87 117.63,95 117.63,121 120.63,124 120.63,131 113.63,138 113.63,152 104.13,161.5 v104.13,163.25
RS232_RXD  (via drill 0.2, 0.5)
  Top 0.254: MSP430F67791.16 122.13,85 112.76,94.38 v110.76,94.38 | v54.63,140.75 36.12,140.75 RX_EN.2
  Bottom 0.254: v54.63,140.75 60.38,135 87.63,135 104.88,117.75 108.88,117.75 109.63,117 109.63,95.5 v110.76,94.38
RS232_TXD  (via drill 0.2, 0.5)
  Top 0.254: MSP430F67791.17 122.63,85.5 113.13,95 111.13,95 v110.63,95.5 | v53.88,143.25 36.16,143.25 TX_EN.2
  Bottom 0.254: v110.63,95.5 110.63,117.5 109.38,118.75 105.38,118.75 88.13,136 61.13,136 v53.88,143.25
RTCCLK  (via drill 0.2)
  Top 0.254: SV2.2 147.24,98.61 146.63,98 146.63,76 146.13,75.5 v145.13,75.5 | v105.38,82.5 MSP430F67791.92 | v140.63,71.5 141.63,71.5 142.13,72 v142.13,75.5
  Bottom 0.254: v140.63,71.5 130.13,71.5 127.13,75 121.97,75 118.63,78.34 118.63,80 116.63,82 114.13,82 113.63,81.5 106.38,81.5 v105.38,82.5 105.63,82.5 | v142.13,75.5 v145.13,75.5
S0
  Top 0.254: MSP430F67791.87 101.13,85 94.13,92 94.13,104.5 91.13,107.5 62.86,107.5 53.71,116.66 LCD1.1
S1
  Top 0.254: MSP430F67791.86 101.38,85.5 94.63,92.25 94.63,104.75 91.38,108 64.88,108 56.23,116.66 LCD1.2
S2
  Top 0.254: MSP430F67791.85 101.63,86 95.13,92.5 95.13,105 91.63,108.5 66.88,108.5 58.73,116.66 LCD1.3
S3
  Top 0.254: MSP430F67791.84 101.88,86.5 95.63,92.75 95.63,105.25 91.88,109 68.88,109 LCD1.4
S4
  Top 0.254: MSP430F67791.83 102.13,87 96.13,93 96.13,105.5 92.13,109.5 70.88,109.5 63.77,116.62 LCD1.5
S5
  Top 0.254: MSP430F67791.82 102.38,87.5 96.63,93.25 96.63,105.75 92.38,110 72.88,110 66.31,116.58 LCD1.6
S6
  Top 0.254: MSP430F67791.81 102.63,88 97.13,93.5 97.13,106 92.63,110.5 74.88,110.5 68.85,116.54 LCD1.7
S7
  Top 0.254: MSP430F67791.80 102.88,88.5 97.63,93.75 97.63,106.25 92.88,111 76.88,111 71.39,116.5 LCD1.8
S8
  Top 0.254: MSP430F67791.79 103.13,89 98.13,94 98.13,106.5 93.13,111.5 78.88,111.5 73.93,116.46 LCD1.9
S9
  Top 0.254: MSP430F67791.78 103.38,89.5 98.63,94.25 98.63,106.75 93.38,112 80.88,112 76.47,116.42 LCD1.10
S10
  Top 0.254: MSP430F67791.77 103.63,90 99.13,94.5 99.13,107 93.63,112.5 82.88,112.5 79.01,116.38 LCD1.11
S11
  Top 0.254: MSP430F67791.76 103.88,90.5 99.63,94.75 99.63,107.25 93.88,113 84.88,113 81.55,116.34 LCD1.12
S12
  Top 0.254: MSP430F67791.75 104.13,91 100.13,95 100.13,107.5 94.13,113.5 86.88,113.5 84.09,116.32 LCD1.13
S13
  Top 0.254: MSP430F67791.74 104.38,91.5 100.63,95.25 100.63,107.75 94.38,114 88.88,114 86.63,116.26 LCD1.14
S14
  Top 0.254: MSP430F67791.73 104.63,92 101.13,95.5 101.13,108 94.63,114.5 90.88,114.5 89.17,116.24 LCD1.15
S15
  Top 0.254: MSP430F67791.72 104.88,92.5 101.63,95.75 101.63,108.25 94.88,115 92.88,115 91.71,116.2 LCD1.16
S16
  Top 0.254: MSP430F67791.71 105.13,93 102.13,96 102.13,108.5 94.25,116.41 LCD1.17
S17
  Top 0.254: MSP430F67791.68 104.38,94.5 102.63,96.25 102.63,108.75 96.79,114.55 LCD1.18
S18
  Top 0.254: MSP430F67791.67 104.63,95 103.13,96.5 103.13,109 99.33,112.83 LCD1.19
S19
  Top 0.254: MSP430F67791.66 104.88,95.5 103.63,96.75 103.63,109.25 101.87,111.04 LCD1.20
S20
  Top 0.254: MSP430F67791.65 105.13,96 104.13,97 104.13,116.38 LCD1.21
S21
  Top 0.254: MSP430F67791.64 109.63,116 109.13,116.5 108.94,116.7 106.99,116.7 LCD1.22
S22  (via drill 0.36)
  Top 0.254: MSP430F67791.63 110.13,116.5 107.13,119.5 v106.63,119.5
  Bottom 0.254: v106.63,119.5 106.63,146.31 LCD1.23
S23  (via drill 0.36)
  Top 0.254: MSP430F67791.62 110.63,116.75 106.88,120.5 v105.63,120.5
  Bottom 0.254: v105.63,120.5 105.63,145.4 LCD1.24
S24  (via drill 0.36)
  Top 0.254: MSP430F67791.61 111.13,117 106.63,121.5 v104.63,121.5
  Bottom 0.254: v104.63,121.5 104.63,133.5 91.71,146.38 LCD1.29
S25  (via drill 0.36)
  Top 0.254: MSP430F67791.60 111.63,117.25 106.38,122.5 v103.63,122.5
  Bottom 0.254: v103.63,122.5 103.63,133.75 93.38,144 91.63,144 89.17,146.47 LCD1.30
S26  (via drill 0.36)
  Top 0.254: MSP430F67791.59 112.13,117.5 106.13,123.5 v102.63,123.5
  Bottom 0.254: v102.63,123.5 102.63,134 93.13,143.5 89.63,143.5 86.63,146.51 LCD1.31
S27  (via drill 0.36)
  Top 0.254: MSP430F67791.58 112.63,117.75 105.88,124.5 v101.63,124.5
  Bottom 0.254: v101.63,124.5 101.63,134.25 92.88,143 87.63,143 84.09,146.55 LCD1.32
S28  (via drill 0.36)
  Top 0.254: MSP430F67791.57 113.13,118 105.63,125.5 v100.63,125.5
  Bottom 0.254: v100.63,125.5 100.63,134.5 92.63,142.5 85.63,142.5 81.55,146.59 LCD1.33
S29  (via drill 0.36)
  Top 0.254: MSP430F67791.56 113.63,118.25 105.38,126.5 v99.63,126.5
  Bottom 0.254: v99.63,126.5 99.63,134.75 92.38,142 83.63,142 LCD1.34
S30  (via drill 0.36)
  Top 0.254: MSP430F67791.55 114.13,118.5 105.13,127.5 v98.63,127.5
  Bottom 0.254: v98.63,127.5 98.63,135 92.13,141.5 81.63,141.5 76.51,146.63 LCD1.35
S31  (via drill 0.36)
  Top 0.254: MSP430F67791.54 114.63,118.75 104.88,128.5 v97.63,128.5
  Bottom 0.254: v97.63,128.5 97.63,135.25 91.88,141 79.63,141 74.01,146.63 LCD1.36
S32  (via drill 0.36)
  Top 0.254: MSP430F67791.53 115.13,119 104.63,129.5 v96.63,129.5
  Bottom 0.254: v96.63,129.5 96.63,135.5 91.63,140.5 77.63,140.5 71.51,146.63 LCD1.37
S33  (via drill 0.36)
  Top 0.254: MSP430F67791.52 115.63,119.25 104.38,130.5 v95.63,130.5
  Bottom 0.254: v95.63,130.5 95.63,135.75 91.38,140 75.63,140 69.01,146.63 LCD1.38
S34  (via drill 0.36)
  Top 0.254: MSP430F67791.51 116.13,119.5 104.13,131.5 v94.63,131.5
  Bottom 0.254: v94.63,131.5 94.63,136 91.13,139.5 73.38,139.5 66.31,146.58 LCD1.39
S35  (via drill 0.36)
  Top 0.254: MSP430F67791.50 116.63,119.75 103.88,132.5 v93.63,132.5
  Bottom 0.254: v93.63,132.5 93.63,136.25 90.88,139 71.38,139 63.77,146.62 LCD1.40
S36  (via drill 0.36)
  Top 0.254: MSP430F67791.49 117.13,120 103.63,133.5 v92.63,133.5
  Bottom 0.254: v92.63,133.5 92.63,136.5 90.63,138.5 69.38,138.5 61.26,146.63 LCD1.41
S37  (via drill 0.36)
  Top 0.254: MSP430F67791.48 117.63,120.25 103.38,134.5 v91.63,134.5
  Bottom 0.254: v91.63,134.5 91.63,136.75 90.38,138 67.38,138 58.76,146.63 LCD1.42
S38  (via drill 0.36)
  Top 0.254: MSP430F67791.47 118.13,120.5 103.13,135.5 v90.63,135.5
  Bottom 0.254: v90.63,135.5 90.63,137 90.13,137.5 65.38,137.5 56.26,146.63 LCD1.43
S39  (via drill 0.36)
  Top 0.254: MSP430F67791.46 118.63,120.75 102.88,136.5 v89.63,136.5
  Bottom 0.254: v89.63,136.5 89.13,137 63.13,137 53.61,146.53 LCD1.44
SCL  (via drill 0.3)
  Top 0.254: MSP430F67791.13 v126.63,83.5 128.61,85.47 R40.1 132.28,85.33 133.04,85.33 133.6,85.89 IC1.6
  Bottom 0.254: v126.63,83.5 136.7,83.5 137.77,84.56 138.15,84.95 138.18,84.98 JP2.1
SDA  (via drill 0.3)
  Top 0.254: MSP430F67791.14 125.38,84 v126.01,84.62 128.38,87 131.98,87 R41.1 IC1.5
  Bottom 0.254: JP2.2 138.94,87.52 136.12,84.69 126.07,84.69 v126.01,84.62
SMCLK  (via drill 0.2)
  Top 0.254: MSP430F67791.6 122.13,80 v121.63,79.5
  Bottom 0.254: v121.63,79.5 123.63,79.5 124.63,80.5 124.63,85 125.13,85.5 135.63,85.5 140.89,90.75 153.02,90.75 SV2.5
TCK
  Top 0.254: R48.1 19.08,118.03 19.6,118.56 JP6.3
  Bottom 0.254: JP6.3 20.37,118.56 16.56,122.38 13.38,122.38 JTAG.7
TDI
  Bottom 0.254: JP8.3 20.37,123.64 16.51,127.5 13.34,127.5 JTAG.3
TDO
  Top 0.254: JP9.3 22.91,124.91 24.82,124.91 25.45,124.28 25.45,117.29 JP5.1
  Bottom 0.254: JP9.3 20.37,126.18 16.56,129.99 13.39,129.99 JTAG.1
TEST/SBWTCK
  Top 0.254: MSP430F67791.97 105.38,80 93.63,91.75 93.63,104.25 90.88,107 60.7,106.96 55.66,112 25.63,112 24.18,113.45 JP4.2 JP4.3 20.37,112.21 17.83,112.21 16.56,113.48 16.56,121.73 JTAG.8
TMS
  Bottom 0.254: JP7.3 20.37,121.1 16.6,124.88 13.42,124.88 JTAG.5
UART_RX  (via drill 0.5)
  Top 0.254: R70.1 49.24,159.29 | R70.1 R71.2 | R70.1 49.38,158.25 v47.63,156.5 | U2.6 49.17,159.37 R70.1
  Bottom 0.254: v47.63,156.5 44.63,153.5 44.63,145 41.6,141.97 RX_EN.1
UART_TX  (via drill 0.5)
  Top 0.254: R69.1 51.48,157.65 v51.13,158 | TX_EN.1 44.29,144.51 46.2,146.41 46.2,147.43 v46.13,147.5
  Bottom 0.254: v46.13,147.5 46.13,153 v51.13,158
V1+
  Top 0.254: MSP430F67791.103 109.63,75 102.63,68
  Top 0.406: 102.63,68 102.63,59 100.63,57 54.88,57 47.38,49.5 47.38,47 48.08,46.3 C8.1
  Top 0.679: C8.1 C1.1 49.23,43.6 R14.1
V1-
  Top 0.254: MSP430F67791.104 110.13,74.75 103.63,68.25 103.63,68
  Top 0.406: 103.63,68 103.63,58.5 101.13,56 61.63,56 55.13,49.5 R32.1
  Top 0.61: 54.78,48.2 R32.1
  Top 0.679: C8.2 C9.1 54.78,48.2
V2+
  Top 0.254: MSP430F67791.105 110.63,74.5 104.63,68.5 104.63,68
  Top 0.406: 104.63,68 104.63,58 101.63,55 64.88,55 59.38,49.5 59.38,47 60.08,46.3 C10.1
  Top 0.61: C2.1 C10.1
  Top 0.679: R16.1 61.23,43.6 C2.1
V2-
  Top 0.254: MSP430F67791.106 111.13,74.25 105.63,68.75 105.63,68
  Top 0.406: 105.63,68 105.63,57.5 102.13,54 71.63,54 67.03,49.4 67.03,48.2
  Top 0.61: 67.03,48.2 R33.1
  Top 0.679: C10.2 C11.1 67.03,48.2
V3+
  Top 0.254: MSP430F67791.107 111.63,74 106.63,69 106.63,68
  Top 0.406: 106.63,68 106.63,57 102.63,53 75.13,53 71.63,49.5 71.63,47 72.33,46.3 C12.1
  Top 0.679: C12.1 C3.1 73.48,43.6 R18.1
V3-
  Top 0.254: MSP430F67791.108 112.13,73.75 107.63,69.25 107.63,68
  Top 0.406: 107.63,68 107.63,56.5 103.13,52 84.05,52 84.05,51.93 83.79,51.67 83.79,49.89 82,48.1 R34.1
  Top 0.61: 78.78,48.2 R34.1
  Top 0.679: C12.2 C13.1 78.78,48.2
VASYS1/2
  Top 0.254: C23.1 112.13,69.25 111.98,69.1 C22.1 110.63,70 113.63,73 MSP430F67791.111 113.63,77.5 114.13,78 118.63,78 119.13,77.5 119.13,76.5 MSP430F67791.122 119.13,73.6 120.73,72 122.63,72 122.87,71.76 C32.1
  Top 0.406: C32.1 122.87,70.76 122.88,70.75 C28.1
VCC_ISO
  Top 0.61: JP3.1 82.75,84.56 ZD3.C C42.1 C101.+
  Top 0.679: C101.+ 79.96,78.3 U$1.VO+
VCC_PL  (via drill 0.6)
  Top 1.016: JP3.3 77.67,87.97
  other vias: 66.13,88.75 67.38,88.75 67.31,90.26 66.06,90.26
  pour Top (no thermals): 60.13,89.5 61.63,89.5 61.63,90.75 78.63,90.75 78.63,87 77.13,87 75.88,88.25 60.13,88.25
  pour Bottom (no thermals): 58.13,90.75 58.13,88.25 75.88,88.25 77.13,87 78.63,87 78.63,90.75
VCORE
  Top 0.254: C38.1 123.63,75.5 123.63,75.7 MSP430F67791.128
VMON  (via drill 0.2, 0.41)
  Top 0.254: MSP430F67791.34 119.13,94 116.88,96.25 109.76,96.25 v108.51,97.5
  Top 0.406: R45.1 87.04,97.19 87.09,97.14 87.03,97.07 87.03,96.12 | R44.2 87.03,96.12 | 87.03,96.12 87.09,96.12 87.35,95.87 v88.11,95.87
  Bottom 0.254: v108.51,97.5 89.74,97.5 v88.11,95.87
VREF
  Top 0.254: MSP430F67791.113 114.63,73.75 114.13,73.25 114.13,72.5 113.63,72 C30.1
VSUPPLY
  Top 0.254: U3.2 51.38,95.51 R35.2
  Top 0.406: R45.2 87.03,103.05 86.33,103.74 57.63,103.74 53.37,103.74 51.38,101.75 R35.2
  Bottom 1.016: D18.C 7.37,100.24 10.13,103 21.88,103 | 21.88,103 23.13,103 | 23.13,103 24.63,103 | 24.63,103 37.88,103 | 37.88,103 39.63,103 | 39.63,103 40.88,103 | 40.88,103 41.63,103 44.38,100.25 44.56,100.08 C102.+ | D22.C 39.41,102.77 39.63,103 | D22.C 39.41,101.52 40.88,103 | D22.C 39.41,101.48 37.88,103 | D20.C 23.2,102.93 23.13,103 | D20.C 23.2,101.57 24.63,103 | D20.C 23.2,101.68 21.88,103
  pour Top (no thermals): 43.63,97.5 45.13,97.5 46.13,96.5 51.63,96.5 51.63,95 50.13,95 50.13,94.5 44.63,94.5 43.13,96 43.13,97
XIN
  Top 0.254: MSP430F67791.1 126.13,77.5 126.98,76.65 128.53,76.65 XT1.P2 130.63,76.5 131.53,75.6 C37.1 131.53,75.1
XOUT
  Top 0.254: XT1.P1 128.53,79.19 | MSP430F67791.2 126.13,78 127.13,79 XT1.P1 | XT1.P1 130.68,79 131.49,79.81 131.49,80.46 C40.1

## Text on the board
tPlace: 2V MAX | 2V MAX | 2V MAX | 2V MAX | 120/240 Vrms | 120/240 Vrms | 120/240 Vrms | 50/60 Hz | 50/60 Hz | 50/60 Hz
tNames: DGND | + | ACT | + | 1 | + | + | DGND | + | 1 | + | REACT | + | ACTIVE | REACTIVE | ISOLATED | M. THRUN / MAY 2012 | M. MESGANAW / AUGUST 2013 | A. GHOSH / APRIL 2014 | 1 | + | + | + | + | + | + | + | + | RS232 | DVCC | INTERNAL | EXTERNAL | J=JTAG | J | S | S=SBW | DGND | DVCC | RTCCLK | ACLK | MCLK | SMCLK | VCC_PL | VCC_ISO | SDA | SCL | CBOUT | DGND | DGND | DIODE | AUXVCC3 | VDSYS | AUXVCC2 | AUXVCC1 | DGND | VBAT | CURRENT | VOLTAGE | Danger | Danger | High Voltage | High Voltage | MSP430F6779 3-Phase Rogowski Coil Energy Meter
_tplace: R90 | R91 | R89 | R88 | EZ-RF | DVCC | R86 | DGND | R85 | RS-232 | R87 | R84 | C59 | R83 | R82 | OPTO2 | R78 | R81 | DGND | R77 | C58 | R80 | R73 | R79 | + | R75 | R76 | ACT | + | D27 | R74 | ACT | C55 | C56 | 1 | U2 | + | + | R70 | R71 | C57 | 1 | 1 | R72 | D26 | OPTO1 | 5 | RF1 | RF2 | DGND | 9 | + | D25 | 1 | 4 | D24 | + | REACT | 8 | + | R69 | ACTIVE | REACTIVE | ISOLATED | REACT | 3 | U1 | LED1 | LED2 | LED3 | LED_ACT | LED_REACT | LED4 | LED5 | LED6 | R68 | R67 | C54 | Q2 | M. THRUN / MAY 2012 | M. MESGANAW / AUGUST 2013 | A. GHOSH / APRIL 2014 | 7 | 2 | R66 | R65 | BTN3 | BTN4 | 6 | R63 | 1 | R64 | 1 | R54 | + | R55 | + | R56 | + | R57 | + | R58 | + | R59 | + | R60 | + | R61 | + | Q1 | R62 | TX_EN | RX_EN | R52 | R53 | RS232 | DVCC | 1 | 2 | INTERNAL | EXTERNAL | BTN1 | BTN2 | RESET | 14 | R51 | R49 | R50 | LCD1 | R48 | C53 | IRDA | J=JTAG | J | S | S=SBW | C52 | JTAG | R47 | C51 | D23 | DGND | DVCC | R46 | RTCCLK | C47 | C36 | R95 | R43 | * | R45 | ACLK | C61 | C60 | C49 | R35 | U3 | MCLK | R98 | R42 | D18 | C48 | R44 | D19 | D20 | D21 | D22 | R97 | SMCLK | R37 | C45 | R38 | VCC_PL | VCC_ISO | R96 | R41 | IC1 | SDA | JP3 | MSP430F67791 | C62 | R40 | ZD3 | SCL | D17 | C43 | C44 | R39 | R100 | R99 | R4 | C40 | CBOUT | C42 | C41 | C38 | XT1 | C34 | C35 | 26 | 22 | VO+ | VO- | C37 | C30 | C31 | C32 | C33 | DGND | DGND | R92 | R94 | R93 | C22 | C23 | DIODE | AUXVCC3 | VDSYS | C29 | C28 | C39 | C46 | C50 | C24 | C25 | C26 | C27 | D44 | AUXVCC2 | AUXVCC1 | L | N | R36 | NC | DGND | VBAT | CURRENT | VOLTAGE | R103 | R101 | R102 | C9 | C8 | R32 | C10 | C11 | R33 | C12 | C13 | R34 | C1 | R14 | R15 | C2 | R16 | R17 | C3 | R18 | R19 | R10 | R7 | R13 | R6 | R9 | R12 | R8 | R5 | R11 | L6 | Danger | Danger | L3 | L5 | L1 | High Voltage | High Voltage | TVS1 | TVS2 | TVS3 | TVS4 | D1 | R1 | R2 | R3 | IN+ | IN- | I1+ | I1- | I2+ | I2- | I3+ | I3- | 2V MAX | 2V MAX | 2V MAX | 2V MAX | LINE1 | LINE2 | LINE3 | 120/240 Vrms | 120/240 Vrms | 120/240 Vrms | MSP430F6779 3-Phase Rogowski Coil Energy Meter | 50/60 Hz | 50/60 Hz | 50/60 Hz | NEUTRAL
_bplace: C102 | L7 | C101 | C100 | C63 | + | AUXVCC1 | - | GND